<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\QuadroHT15_v2-1.ewp</path>
  <batchBuild />
</workspace>
